# IAR project rtc32_example1.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-5s-xmega-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: F_CPU=32000000
  ICCAVR.newCCIncludePaths: ..\; ..\Drv\
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgxm256a3b.xcl
configuration Release (AVR)
  as the first configuration, except:
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\lnk0t.xcl
  XLINK.XExtraOptions: -y(CODE); -Ointel-extended,(DATA)=$EXE_DIR$\$PROJ_FNAME$_data.hex; -Ointel-extended,(XDATA)=$EXE_DIR$\$PROJ_FNAME$_eeprom.hex
  group (top)
    ./: rtc32_example1.c
  group Drv
    ../Drv/: rtc32_driver.c rtc32_driver.h vbat.c vbat.h
